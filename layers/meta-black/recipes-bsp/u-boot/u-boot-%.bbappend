FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "\
	file://myown_defconfig \
	"

